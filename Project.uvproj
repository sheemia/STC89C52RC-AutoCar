# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c GrayscaleSensor.c I2C.c oled.c Key.c Timer2.c Menu.c Task1.c Motor.c Task2.c Task3.c Task4.c Task5.c Task6.c Task7.c UART_JY61P.c Motor_PID.c Gyro_PID.c Driving.c Home.c
